## app/boards/shields/calla60/Kconfig.shield
```kconfig
# Copyright (c) 2021 310weber
# SPDX-License-Identifier: MIT

config SHIELD_CALLA60
    def_bool $(shields_list_contains,calla60)
```
